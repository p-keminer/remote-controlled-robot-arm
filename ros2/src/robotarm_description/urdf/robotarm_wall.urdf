Commit message: feat: add potentiometer mapping and ROS debug stack

File: ros2/src/robotarm_description/urdf/robotarm_wall.urdf (robot description, URDF)
Before this commit: robot adeept_5dof_wall, 19 links, 18 joints
Links:
- link wall: geometry visual box size=0.18 0.005 0.18
